Commit message: added synthetic camera aruco prediction

File: visual/aruco.urdf (robot description, URDF)
Before this commit: robot cube.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry visual box size=0.1 0.1 0.01
